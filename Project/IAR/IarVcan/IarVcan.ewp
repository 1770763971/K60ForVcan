# IAR project IarVcan.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\..\Libralies\Chip; ..\..\..\Libralies\FatFs; ..\..\..\Libralies\Startup\IAR; ..\..\..\Libralies\Startup\kinetis; ..\..\..\Libralies\Vcan; ..\..\User; ..\..\..\Libralies\Startup\core; ..\..\..\Libralies\Startup; ..\..\Code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: IarVcan.srec
  ILINK.IlinkOutputFile: IarVcan.out
  ILINK.IlinkIcfFile: ..\..\..\Libralies\Startup\config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Libraries/Chip
    ../../../Libralies/Chip/: common.h misc.c misc.h MK60_adc.c MK60_adc.h MK60_can.c MK60_can.h MK60_dac.c MK60_dac.h MK60_dma.c MK60_dma.h MK60_DWT.c MK60_DWT.h MK60_flash.c MK60_FLASH.h MK60_flexbus.c MK60_ftm.c MK60_FTM.h MK60_gpio.c MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.c MK60_i2c.h MK60_lptmr.c MK60_lptmr.h MK60_mcg.c MK60_mcg.h MK60_PIT.c MK60_pit.h MK60_port.c MK60_port.h MK60_rtc.c MK60_rtc.h MK60_spi.c MK60_spi.h MK60_SysTick.c MK60_SysTick.h MK60_uart.c MK60_uart.h MK60_wdog.c MK60_wdog.h vectors.c vectors.h
  group Libraries/Startup
    ../../../Libralies/Startup/: MK60_conf.c MK60_conf.h
    ../../../Libralies/Startup/IAR/: startup_MK60DZ10.s system_MK60DZ10.c system_MK60DZ10.h
  group Libraries/Vcan
    ../../../Libralies/Vcan/: VCAN_ASCII.c VCAN_camera.c VCAN_camera.h VCAN_computer.c VCAN_computer.h vcan_img2sd.c VCAN_key.c VCAN_key.h VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ILI9325.c VCAN_LED.C VCAN_MMA7455.c VCAN_MMA7455.h VCAN_NRF24L0.c VCAN_NRF24L0.h VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_RTC_count.h VCAN_SCCB.c VCAN_SCCB.h vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Project/Code
    ../../Code/: Image_Processing.cpp Screen.c
  group Project/User
    ../../User/: main.c Main.h MK60_it.c MK60_it.h
